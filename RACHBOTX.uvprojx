# Keil uVision project RACHBOTX.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RACHBOTX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;..\FIRMWARE KEIL;..\trunk
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source
    ./Source/: Flash.c Leds.c motores.c Tartea_Control.c Tartea_Sensores.c Tartea_Telemetria.c Turbina.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F042K6Tx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F042K6Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, Device:STM32Cube HAL 1.7.0
